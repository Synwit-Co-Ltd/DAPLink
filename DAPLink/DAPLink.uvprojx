# Keil uVision project DAPLink.uvprojx, settings and files
target DAPLink-HID (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.20.3
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: DAPLink-HID
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c define: DAP_FW_V1
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM341_StdPeriph_Driver;.\APP;.\APP\DAP;.\APP\SWD_host
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./app/: main.c
    ./APP/: descriptors.c hid_transfer.c vcom_serial.c
  group DAP
    ./APP/DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group SWD_host
    ./APP/SWD_host/: SWD_host.c
  group CSL\StdPD
    ./CSL/SWM341_StdPeriph_Driver/: SWM341_port.c SWM341_gpio.c SWM341_exti.c SWM341_timr.c SWM341_uart.c SWM341_adc.c SWM341_dma.c SWM341_i2c.c SWM341_pwm.c SWM341_can.c SWM341_spi.c SWM341_lcd.c SWM341_flash.c SWM341_crc.c SWM341_rtc.c SWM341_wdt.c SWM341_cordic.c SWM341_sleep.c SWM341_usbd.c SWM341_div.c SWM341_sdio.c SWM341_sdram.c SWM341_dac.c SWM341_jpeg.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
target DAPLink-WINUSB (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.20.3
  cpu: as above
  output: DAPLink-WINUSB
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
